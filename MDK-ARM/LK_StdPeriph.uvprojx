# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 07x Project (6230000::V6.23::ARMCLANG)
  device: LKS32MC071C8T8 Linko
  pack: Linko.LKS07x.1.2.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LK_StdPeriph +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\lks32mc07x_periph_driver\Include;..\0_Include;..\1_LKS_FwLib\lks32mc07x_periph_driver\Include;..\1_LKS_FwLib\lks32mc07x_periph_driver\hal\include;..\2_HardwareDriverLayer;..\3_CommonServiceLayer;..\4_MotorDriveLayer;..\5_MotorAppLayer;..\6_UserAppLayer
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Start
    ../1_LKS_FwLib/lks32mc07x_periph_driver/Source/: startup_lks32mc07x.s
  group 0_Include
    ../0_Include/: sysdef.h
  group 1_LKS_FwLib
    ../1_LKS_FwLib/lks32mc07x_periph_driver/Source/: lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_clu.c lks32mc07x_cmp.c lks32mc07x_crc.c lks32mc07x_dac.c lks32mc07x_dma.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32MC07x_flash.c lks32mc07x_gpio.c lks32mc07x_hall.c lks32mc07x_i2c.c lks32mc07x_mcpwm.c lks32mc07x_nvr.lib lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_spi.c lks32mc07x_sys.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_wake.c lks32mc07x_uart.c
  group 2_HardwareDriverLayer
    ../2_HardwareDriverLayer/: hardware_init.c
  group 3_CommonServiceLayer
    ../3_CommonServiceLayer/: led.c uart.c vofa.c
  group 4_MotorDriveLayer
    ../4_MotorDriveLayer/: AdcCalc.c Clark_Park.c Foc.c Hall.c MotShuntSample.c PID.c Svpwm.c Speedloop.c
  group 5_MotorAppLayer
    ../5_MotorAppLayer/: GlobalVariable.c Multifunction.c SysInit.c
  group 6_UserAppLayer
    ../6_UserAppLayer/: interrupt.c main.c TaskScheduler.c
target Linko 07x Project_ac6 (6160000::V6.16::ARMCLANG)
  device: LKS32MC071CBT8 Linko
  pack: Linko.LKS07x.1.2.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LK_StdPeriph +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=7 v6Lto=1 wLevel=3
  c include: .\Include;.\LKS32MC08x_Periph_Driver\Include;.\FreeMaster;.\RTT;.\ac6
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
software components: CMSIS:CORE 6.2.0
